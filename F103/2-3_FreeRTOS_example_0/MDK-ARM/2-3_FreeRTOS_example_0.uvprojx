# Keil uVision project 2-3_FreeRTOS_example_0.uvprojx, settings and files
target 2-3_FreeRTOS_example_0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 2-3_FreeRTOS_example_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../A_Project_cfg;../BSP;../BSP/Board;../BSP/Board/stm32f103_board;../BSP/Drivers/device;../BSP/Drivers/factory;../BSP/Drivers/interface;../BSP/Drivers/platform/stm32;../Component;../Component/logger;../BSP/Drivers/interface/System/Sys;../Component/utils;../Lib/EasyLogger/easylogger/inc;../Lib/EasyLogger/easylogger/src;../BSP/Drivers/interface/Device;../Test/core;../Test
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\2-3_FreeRTOS_example_0\2-3_FreeRTOS_example_0.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c usb.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group BSP
    ../BSP/: BSP_init.c BSP_init.h
  group Map
    ../BSP/Board/: dev_map.h dev_map_config.h
    ../BSP/Board/stm32f103_board/: stm32f103_board_v1.c
  group interface
    ../BSP/Drivers/interface/: interface_inc.h
  group device
    ../BSP/Drivers/device/: device_inc.h
    ../BSP/Drivers/device/oled/chip/: oled_drv_ssd1306.c
    ../BSP/Drivers/device/oled/: oled_driver.c oled_font.c
    ../BSP/Drivers/device/oled/bus/: oled_i2c_bus.c oled_spi_bus.c
  group factory
    ../BSP/Drivers/factory/: factory_inc.h
    ../BSP/Drivers/factory/connectivity/src/: gpio_factory.c i2c_factory.c spi_factory.c usart_factory.c
    ../BSP/Drivers/factory/device/src/: OLED_factory.c
    ../BSP/Drivers/factory/timer/src/: timer_factory.c
  group platform
    ../BSP/Drivers/platform/stm32/: stm32_inc.h
    ../BSP/Drivers/platform/stm32/System/: System_port.h
    ../BSP/Drivers/platform/stm32/System/Sys/: stm32_sys.c stm32_sys.h
    ../BSP/Drivers/platform/stm32/Connectivity/gpio/: stm32_gpio_driver.c
    ../BSP/Drivers/platform/stm32/Connectivity/i2c/: stm32_i2c_driver.c stm32_i2c_soft_driver.c
    ../BSP/Drivers/platform/stm32/Connectivity/spi/: stm32_spi_driver.c
    ../BSP/Drivers/platform/stm32/Connectivity/timer/: stm32_timer_driver.c
    ../BSP/Drivers/platform/stm32/Connectivity/usart/: stm32_usart_driver.c
  group Component
    ../Component/uart_queue/: uart_queue.c uart_queue.h
    ../Component/utils/ring_buffer/: ring_buffer.c ring_buffer.h
    ../Component/logger/: elog_init.h elog_init.c elog_port.c
    ../Component/: Component_inc.h
  group Lib
    ../Lib/EasyLogger/easylogger/inc/: elog.h elog_cfg.h
    ../Lib/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Test
    ../Test/core/: test_framework.c test_framework.h
    ../Test/: test_config.h
    ../Test/Unit/: test_led.c
software components: CMSIS:CORE 4.3.0
