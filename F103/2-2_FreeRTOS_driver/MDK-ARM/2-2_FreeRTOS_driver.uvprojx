# Keil uVision project 2-2_FreeRTOS_driver.uvprojx, settings and files
target 2-2_FreeRTOS_driver (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 2-2_FreeRTOS_driver +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP/Drivers/device/oled;../BSP/Drivers/factory/connectivity/inc;../BSP/Drivers/factory/device/inc;../BSP/Drivers/factory/timer;../BSP/Drivers/interface/Connectivity;../BSP/Drivers/interface/System/Sys;../BSP/Drivers/interface/Timer;../BSP/Drivers/interface/Device;../BSP/A_Project_cfg;../Component/uart_queue;../Component/logger;../UserApp;../BSP;../Component;../BSP/Board;../Lib/EasyLogger;../Lib/EasyLogger/easylogger/inc;../BSP/Drivers/platform/stm32/Connectivity;../BSP/Drivers/platform/stm32/System;..\BSP\Drivers\platform\stm32\System\Sys;..\Component\utils;..\Test;..\BSP\Drivers\device
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group UserApp
    ../UserApp/: user_task.c user_task.h
  group BSP
    ../BSP/: BSP_init.c BSP_init.h
  group BSP\Drivers\interface
    ../BSP/Drivers/interface/System/Sys/: Sys.h
    ../BSP/Drivers/interface/Connectivity/: gpio_driver.h i2c_driver.h spi_driver.h usart_driver.h
    ../BSP/Drivers/interface/Timer/: timer_driver.h
    ../BSP/Drivers/interface/Device/: oled_driver.h
  group BSP\Drivers\factory
    ../BSP/Drivers/factory/connectivity/inc/: gpio_factory.h i2c_factory.h usart_factory.h
    ../BSP/Drivers/factory/connectivity/src/: gpio_factory.c i2c_factory.c usart_factory.c
    ../BSP/Drivers/factory/timer/: timer_factory.c timer_factory.h
    ../BSP/Drivers/factory/device/inc/: OLED_factory.h
    ../BSP/Drivers/factory/device/src/: OLED_factory.c
  group BSP\Drivers\device\oled
    ../BSP/Drivers/device/oled/: oled_driver.c oled_font.c oled_font.h
    ../BSP/Drivers/device/oled/chip/: oled_drv_ssd1306.c oled_drv_ssd1306.h
    ../BSP/Drivers/device/oled/bus/: oled_i2c_bus.c oled_i2c_bus.h
  group BSP\Drivers\platform
    ../BSP/Drivers/platform/stm32/System/: System_port.h
    ../BSP/Drivers/platform/stm32/System/Sys/: stm32_sys.c stm32_sys.h
    ../BSP/Drivers/platform/stm32/Connectivity/gpio/: stm32_gpio_driver.c stm32_gpio_driver.h
    ../BSP/Drivers/platform/stm32/Connectivity/i2c/: stm32_i2c_driver.c stm32_i2c_driver.h stm32_i2c_soft_driver.c
    ../BSP/Drivers/platform/stm32/Connectivity/timer/: stm32_timer_driver.c stm32_timer_driver.h
    ../BSP/Drivers/platform/stm32/Connectivity/usart/: stm32_usart_driver.c stm32_usart_driver.h
  group Component
    ../Component/uart_queue/: uart_queue.c uart_queue.h
    ../Component/logger/: elog_init.c elog_init.h elog_port.c
  group Lib
    ../Lib/EasyLogger/easylogger/inc/: elog.h elog_cfg.h
    ../Lib/EasyLogger/easylogger/port/: elog_port.c
    ../Lib/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group Test
    ../Test/core/: test_framework.c test_framework.h
    ../Test/: test_config.h
  group A_Project_cfg
    ../BSP/A_Project_cfg/: HAL_include.h Project_cfg.h
  group map
    ../BSP/Board/: dev_map.h dev_map_config.h
    ../BSP/Board/stm32f103_board/: stm32f103_board_v1.c
software components: CMSIS:CORE 4.3.0
